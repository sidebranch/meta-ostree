require ostree.inc

SRC_URI = "gitsm://github.com/ostreedev/ostree.git;branch=master"

SRCREV="ae61321046ad7f4148a5884c8c6c8b2594ff840e"

PV = "v2017.13"

S = "${WORKDIR}/git"
