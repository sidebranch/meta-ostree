require ostree.inc

SRC_URI[md5sum] = "4ef1cee4c98d6f94d6c8220ba070b55f"
SRC_URI[sha256sum] = "beef6debb0065bf1dc7538cd036c5f0348ac102ca4ad6d8651feff146130a844"

